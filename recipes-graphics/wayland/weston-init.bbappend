RRECOMMENDS:${PN}:tegra234 = "kernel-module-nvidia-drm nvidia-drm-loadconf"
